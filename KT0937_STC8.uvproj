# Keil uVision project KT0937_STC8.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: KT0937_STC8 +hex
  c flags: Optimize=8
  group src
    ./: STARTUP.A51
    ./src/: main.c STC8G_H_Delay.c STC8G_H_GPIO.c STC8G_H_I2C.c STC8G_H_I2C_Isr.c STC8G_H_NVIC.c STC8G_H_Timer.c STC8G_H_Timer_Isr.c
  group include
    ./include/: Config.h OLEDFont.h STC8G_H_Delay.h STC8G_H_GPIO.h STC8G_H_I2C.h STC8G_H_NVIC.h STC8G_H_Switch.h STC8G_H_Timer.h STC8H.h Type_def.h
