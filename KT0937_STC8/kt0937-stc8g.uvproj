# Keil uVision project kt0937-stc8g.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: kt0937-stc8g +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c STC8G_H_GPIO.c STC8G_H_I2C.c STC8G_H_I2C_Isr.c STC8G_H_NVIC.c STC8G_H_Soft_I2C.c STC8G_H_Timer.c STC8G_H_Timer_Isr.c STC8G_H_UART.c STC8G_H_UART_Isr.c
